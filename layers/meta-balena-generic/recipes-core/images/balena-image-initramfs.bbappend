PACKAGE_INSTALL_append = " initramfs-module-cryptsetup"
